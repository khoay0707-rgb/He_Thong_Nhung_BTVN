# Keil uVision project FreeRTOS_LED.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS_LED
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: D:\FreeRTOS-Kernel\include;D:\User;D:\FreeRTOS-Kernel\portable\GCC\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    D:/User/: FreeRTOSConfig.h main.c
  group FreeRTOS
    D:/FreeRTOS-Kernel/: tasks.c list.c queue.c timers.c event_groups.c stream_buffer.c
    D:/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    D:/FreeRTOS-Kernel/portable/GCC/ARM_CM3/: port.c
software components: CMSIS:CORE 5.4.0, Device:GPIO 1.3, Device:Startup 1.0.0
